# Keil uVision project template_dualcore_m4.uvprojx, settings and files
target debug (ARM-ADS)
  device: LPC54102:M4 NXP
  pack: Keil.LPC54000_DFP.1.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x02000000,0x10000) IRAM2(0x02010000,0x08000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: img_keil_dualcore_m4 +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: AM_CORTEX_M4 AM_VDEBUG
  c include: ..\..\..\ametal\board;..\..\..\ametal\CMSIS\Include;..\..\..\ametal\common\include;..\..\..\ametal\lpc5410x\drivers\include;..\..\..\ametal\lpc5410x\hw\include;.\user_code;.\user_config;.\user_config\include
  asm define: AM_CORTEX_M4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x2000000 size 0x10000
  memory RVCT10: RAM 0x2010000 size 0x8000
  scatter file: .\shared\lpc5410x.sct
  link misc: --predefine="-DAM_CORTEX_M4"
  group common
    ../../../ametal/common/source/: am_buzzer_pwm.c am_i2c.c am_led.c am_ringbuf.c am_spi.c am_uart.c am_uart_int.c am_uart_ringbuf.c am_adc.c am_dac.c
  group lib
    ../../../ametal/lpc5410x/hw/lib/: lib_power.lib
  group startup
    ../../../ametal/startup/: am_startup_armcc_lpc5410x.s
  group board
    ../../../ametal/board/: am_board.c am_debug.c am_delay.c am_system.c
  group hw
    ../../../ametal/lpc5410x/hw/source/: amhw_adc.c amhw_clock.c amhw_cpuctrl.c amhw_crc.c amhw_fifo.c amhw_iap.c amhw_mbox.c amhw_pint.c amhw_pll.c amhw_rit.c amhw_sct.c amhw_syscon.c amhw_timer.c amhw_usart.c amhw_utick.c
  group drivers
    ../../../ametal/lpc5410x/drivers/source/: amdr_adc.c amdr_crc.c amdr_dma.c amdr_gpio.c amdr_i2c.c amdr_int.c amdr_mrt.c amdr_rit.c amdr_rtc.c amdr_sct_cap.c amdr_sct_pwm.c amdr_sct_timing.c amdr_spi.c amdr_timer_cap.c amdr_timer_pwm.c amdr_timer_timing.c amdr_usart.c amdr_utick.c amdr_wwdt.c
  group user_config
    ./user_config/include/: am_prj_config.h
    ./user_config/source/: amdr_hwconfig_adc.c amdr_hwconfig_crc.c amdr_hwconfig_dma.c amdr_hwconfig_fifo.c amdr_hwconfig_gpio.c amdr_hwconfig_i2c.c amdr_hwconfig_mrt.c amdr_hwconfig_rit.c amdr_hwconfig_rtc.c amdr_hwconfig_sct_cap.c amdr_hwconfig_sct_pwm.c amdr_hwconfig_sct_timing.c amdr_hwconfig_spi.c amdr_hwconfig_timer_cap.c amdr_hwconfig_timer_pwm.c amdr_hwconfig_timer_timing.c amdr_hwconfig_usart.c amdr_hwconfig_utick.c amdr_hwconfig_wwdt.c amdr_hwconfig_int.c
  group user_code_m4
    ./user_code_m4/: main.c
